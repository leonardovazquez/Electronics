options:
  parameters:
    author: Vazquez Leonardo
    generate_options: qt_gui
    id: noise
    output_language: python
    title: Noise Study
  states: {}

blocks:
- name: noise_amp
  id: variable_qtgui_entry
  parameters:
    label: Noise amplitude
    type: real
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/leonardo/Desktop/FACULTAD/TESIS/GNU RADIO/Examples/Noise/Re.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/leonardo/Desktop/FACULTAD/TESIS/GNU RADIO/Examples/Noise/Re.py
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (1,1,1)
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
  states: {}

connections:
- [blocks_vector_source_x_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_vector_to_stream_1, '0', blocks_complex_to_interleaved_char_0, '0']

metadata:
  file_format: 1
